## boards/shields/keeb60/Kconfig.defconfig
```kconfig
if SHIELD_KEEB60

# Name must be less than 16 characters long!
config ZMK_KEYBOARD_NAME
    default "keyboard60"

endif
```
